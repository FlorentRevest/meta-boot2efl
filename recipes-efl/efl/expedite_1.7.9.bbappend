EXTRA_OECONF = "--enable-fb"
RDEPENDS_${PN} = "expedite-themes"
