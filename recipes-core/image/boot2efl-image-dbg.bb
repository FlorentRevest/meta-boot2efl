inherit boot2efl-image
DESCRIPTION = "Boot2EFL image for debuggers, contains debugging tools"
EXTRA_IMAGE_FEATURES += "dbg-pkgs tools-debug tools-testapps debug-tweaks"
