require ${BPN}.inc

SRC_URI = "git://git.enlightenment.org/core/evas_generic_loaders.git/;protocol=https"
SRCREV = "${AUTOREV}"
S = "${WORKDIR}/git/"
